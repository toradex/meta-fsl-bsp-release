require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "a852e0a0b51d088b591b45f4a85f5a09"
SRC_URI[sha256sum] = "14d04ccf963d7b1ace3814ea705bdd425994901f9a5faacfa09473df5606fb4e"

COMPATIBLE_MACHINE = "(mx8)"
