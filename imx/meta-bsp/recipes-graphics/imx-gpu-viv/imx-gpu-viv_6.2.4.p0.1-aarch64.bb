require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "f0b534eabbc7baeb89dcf43be16fc907"
SRC_URI[sha256sum] = "e482bd7cebd52c1f7c29527c7ca96e3f9450b7ae7d30911799755fce5c9688b3"

COMPATIBLE_MACHINE = "(mx8)"
