require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "332ab0592b97265769eb4f21ac38a0bd"
SRC_URI[sha256sum] = "9437f2aef263c47b0c91cbbc42d835436f6f5bd36033f8b6bc5ff97aa9b60c16"

COMPATIBLE_MACHINE = "(mx8)"
